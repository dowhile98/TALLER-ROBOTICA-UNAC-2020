# Keil uVision project configuracion y filtros.uvprojx, settings and files
target stm32f407-DISC1 (6140000::V6.14::ARMCLANG)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: configuracion y filtros
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: __FPU_PRESENT = 1U, ARM_MATH_CM4
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Scr
    ./: main.c stm32f4xx_it.c clock.c
  group Inc
    ./: signal.h main.h fir_lowP.h iir_lowP_lattice.h
software components: CMSIS:CORE 5.4.0, CMSIS:DSP 1.8.0, Device:STM32Cube Framework:Classic 1.7.9, Device:STM32Cube HAL:Common 1.7.9, Device:STM32Cube HAL:Cortex 1.7.9, Device:STM32Cube HAL:GPIO 1.7.9, Device:STM32Cube HAL:PWR 1.7.9, Device:STM32Cube HAL:RCC 1.7.9, Device:Startup 2.6.3
